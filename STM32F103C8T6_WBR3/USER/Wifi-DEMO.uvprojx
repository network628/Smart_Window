# Keil uVision project Wifi-DEMO.uvprojx, settings and files
target Wifi-DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\mcu_sdk;..\HardWare\Uart2_Wifi;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HardWare\Uart3_PM2.5;..\HardWare\IIC;..\HardWare\Is_AQM;..\HardWare\Motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c key.c led.c Time_test.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group mcu_sdk
    ../mcu_sdk/: mcu_api.c protocol.c system.c
  group HardWare
    ../HardWare/Uart2_Wifi/: usart2.c
    ../HardWare/Uart3_PM2.5/: usart3.c
    ../HardWare/IIC/: i2c.c
    ../HardWare/Is_AQM/: Is_AQM.c
    ../HardWare/Motor/: Motor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
